Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-05-04T11:10:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.30.41
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Wed May 04 11:10:50 2022* Host: NCL-PI02* Database: C:\Users\connm\AppData\Local\Temp\{EECAA02B-50EE-4045-AACD-298A260A7829}\ifc* Database version: 5507* Database creation date: Wed May 04 11:10:50 2022* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Wed May 04 11:10:50 2022* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Wed May 04 11:10:50 2022* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFurnishingElement: ElementsTenderToiletBrushSetTVA151016000, NBS_VilleroyAndBochAG_TltBrshHldrs_Elements_Tender_ToiletBrushSet_TVA151016000:ElementsTenderToiletBrushSetTVA151016000:89244
In: Level 1
Type - ElementType: ElementsTenderToiletBrushSetTVA151016000; Classification: Pr_40_20_76_86 (Uniclass2015); Material: NBS_VilleroyAndBochAG_Chrome
Type - BOS_General - Author: NBS; BIMObjectName: NBS_VilleroyAndBochAG_ToiletBrushHolders_Elements_Tender_ToiletBrushSet_TVA151016000; ManufacturerName: Villeroy & Boch AG; ManufacturerURL: https://pro.villeroy-boch.com; NBSCertification: www.nationalbimlibrary.com/cert/ibfqbdkf; ProductInformation: n/a; Uniclass2015Title: Toilet brush holders; Uniclass2015Code: Pr_40_20_76_86; Uniclass2015Version: Products v1.22; Version: 3
Type - NBS_Data - ContainsRedListMaterials: n/a; CountryOfMaterialOrigin: n/a; CountryOfProductManufacture: n/a; EmbodiedCarbon: n/a; FinishAndColour: Gloss chrome; Form: Surface mounted; IntegralAccessories: n/a; Recyclability: n/a; RecycledContent: n/a; Size: n/a
Type - IFC - IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_20_76_86:Toilet brush holders; CodePerformance: n/a; Color: Silver; Constituents: n/a; Description: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Gloss; Grade: n/a; Manufacturer: n/a; Material: Zinc and glass; ModelNumber: n/a; ModelReference: Elements Tender Toilet Brush Set TVA151016000; Name: ToiletBrushHolders_Elements_Tender_ToiletBrushSet_TVA151016000_VilleroyAndBochAG; NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; Barcode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
